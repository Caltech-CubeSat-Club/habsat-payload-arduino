options:
  parameters:
    author: findm
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: baudrate
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: decim
  id: variable
  parameters:
    value: '32'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: samp_rate/baudrate/decim
    ted_gain: '1.47'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    rate: '60'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: decim
    gain: '1'
    ntaps: '101'
    samp_rate: samp_rate
    sym_rate: baudrate
    type: fir_filter_ccf
  states: {}
- name: satellites_crc_check_0
  id: satellites_crc_check
  parameters:
    final_xor: '0xFFFF'
    initial_value: '0x1D0F'
    input_reflected: 'False'
    num_bits: '16'
    poly: '0x1021'
    result_reflected: 'False'
  states: {}
- name: satellites_sync_to_pdu_packed_0
  id: satellites_sync_to_pdu_packed
  parameters:
    packlen: '35'
    sync: '"10010011000010110101000111011110"'
    threshold: '0'
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    amp: 'True'
    center_freq: '433996000'
    gain: '24'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    agc: 'True'
    center_freq: '469200000'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_binary_slicer_fb_0, '0', satellites_sync_to_pdu_packed_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_0, '0']
- [root_raised_cosine_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_sink_x_0, '0']
- [satellites_crc_check_0, ok, blocks_message_debug_0, print]
- [satellites_sync_to_pdu_packed_0, out, satellites_crc_check_0, in]
- [soapy_hackrf_source_0, '0', root_raised_cosine_filter_0, '0']
- [soapy_rtlsdr_source_0, '0', root_raised_cosine_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
